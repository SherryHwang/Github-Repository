# Keil uVision project MCU_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MCU_TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\IIC;.\LCD1602;.\DELAY;.\PCF8591;.\SENSOR;.\USER;.\7SEG;.\WIFI;.\DEFINE;.\DS18B20;.\ELECTRONIC_SCALE;..\MCU_TEST;.\LATTICE;.\ADXL345;.\BH1750
  group Source Group 1
    ./USER/: MAIN.c
    ./IIC/: IIC.c
    ./LCD1602/: LCD1602.c
    ./PCF8591/: PCF8591.c
    ./DELAY/: Delay.c
    ./7SEG/: 7SEG.c
    ./WIFI/: WIFI.c
    ./DS18B20/: DS18B20.c
    ./ELECTRONIC_SCALE/: ELECTRONIC_SCALE.c
    ./ADXL345/: ADXL345.c
    ./LATTICE/: LATTICE.c
    ./BH1750/: BH1750.c
  group SENSOR
    ./SENSOR/: SENSOR.c
